# Keil uVision project Project.uvprojx, settings and files
target Car (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MK66FN2M0xxx18 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) IROM(0x00000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: projet
  AfterMake: fromelf.exe --bin -o  ./bin/@L.bin  ./Objects/@L.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MK66FN2M0VLQ18
  c include: .\RTE\Device\MK66FN2M0xxx18;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\port;..\User\inc;..\Device\hal\inc;..\Device;..\Hardware\inc
  library: MicroLIB
  memory RVCT4: ROM 0x2000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Hal
    ../Device/hal/src/gpio/: fsl_gpio_hal.c
    ../Device/hal/src/sim/MK66F18/: fsl_sim_hal_MK66F18.c
    ../Device/hal/src/port/: fsl_port_hal.c
    ../Device/hal/src/ftm/: fsl_ftm_hal.c
    ../Device/hal/src/i2c/: fsl_i2c_hal.c
    ../Device/hal/src/uart/: fsl_uart_hal.c
    ../Device/hal/src/edma/: fsl_edma_hal.c
    ../Device/hal/src/dmamux/: fsl_dmamux_hal.c
    ../Device/hal/src/adc16/: fsl_adc16_hal.c
  group FreeRTOS
    ../Middlewares/FreeRTOS/src/: croutine.c list.c queue.c tasks.c timers.c heap_1.c heap_2.c heap_3.c heap_4.c
    ../Middlewares/FreeRTOS/port/: port.c
  group Hardware
    ../Hardware/src/: bsp.c mpu6050.c oled_i2c.c OV7725.c SCCB.c uart_debug.c i2c.c key.c
  group User
    ../User/src/: debug.c delay.c fsl_misc_utilities.c irq_service.c kalman_filter.c main.c moter.c os_timers.c pid.c sendwave.c uart_cmd.c mystring.c image_process.c turn.c
  group Device
    ./RTE/Device/MK66FN2M0xxx18/: startup_MK66F18.s system_MK66F18.c system_MK66F18.h
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1
